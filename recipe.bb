# SPDX-License-Identifier: GPL-2.0-only
# Copyright (c) 2024 Upstream
SUMMARY = "test recipe"
